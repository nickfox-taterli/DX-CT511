<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\DX-CT511.ewp</path>
  </project>
  <batchBuild />
</workspace>
